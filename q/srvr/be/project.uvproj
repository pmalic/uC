# Keil uVision project project.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: be
  AfterMake: fromelf --bin -o build\be_LPC1768.bin build\be.axf
  c flags: Optim=3
  c define: TARGET_LPC1768
  c misc: --gnu
  c include: .\mbed;  .\mbed\LPC1768;  .\mbed\LPC1768\ARM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\mbed\LPC1768\ARM\LPC1768.sct
  link misc: .\mbed\LPC1768\ARM\startup_LPC17xx.o
                 
                .\mbed\LPC1768\ARM\sys.o
                 
                .\mbed\LPC1768\ARM\mbed.ar
                 
                .\mbed\LPC1768\ARM\cmsis_nvic.o
                 
                .\mbed\LPC1768\ARM\core_cm3.o
                 
                .\mbed\LPC1768\ARM\capi.ar
                 
                .\mbed\LPC1768\ARM\system_LPC17xx.o
  group src
    ./: main.cpp QHTTPHandler.h QHTTPHandler.cpp
  group MODSERIAL
    ./MODSERIAL/: FLUSH.cpp GETC.cpp ISR_RX.cpp ISR_TX.cpp MACROS.h MODSERIAL.cpp MODSERIAL.h MODSERIAL_IRQ_INFO.cpp PUTC.cpp RESIZE.cpp INIT_.cpp
  group NetServices
    ./NetServices/lwip/core/: dns.c def.c dhcp.c udp.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c
    ./NetServices/api/: UDPSocket.cpp DNSRequest.cpp TCPSocket.cpp
    ./NetServices/core/: netservice.cpp ipaddr.cpp net.cpp
    ./NetServices/dbg/: dbg.cpp
    ./NetServices/drv/eth/: eth_drv.cpp
    ./NetServices/if/eth/: EthernetNetIf.cpp
    ./NetServices/if/lwip/: lwipNetUdpSocket.cpp lwipNetDnsRequest.cpp LwipNetIf.cpp lwipNetTcpSocket.cpp
    ./NetServices/if/net/: netudpsocket.cpp netdnsrequest.cpp netif_.cpp nettcpsocket.cpp
    ./NetServices/lwip/arch/: sys_arch.cpp
    ./NetServices/lwip/core/ipv4/: ip_frag.c autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c
    ./NetServices/lwip/netif/: ethernetif.c etharp.c
    ./NetServices/services/http/server/impl/: FSHandler.cpp
    ./NetServices/services/http/server/: HTTPServer.cpp HTTPRequestDispatcher.cpp HTTPRequestHandler.cpp
    ./NetServices/services/http/util/: urlencode.cpp base64.cpp url.cpp
    ./NetServices/services/ntp/: NTPClient.cpp
  group FATFileSystem
    ./FATFileSystem/: ff.c diskio.c FATDirHandle.cpp FATFileHandle.cpp FATFileSystem.cpp
    ./FATFileSystem/option/: ccsbcs.c
  group SDFileSystem
    ./SDFileSystem/: SDFileSystem.cpp
  group XBee
    ../../../xbee/: Platform.h XBee.cpp XBee.h
